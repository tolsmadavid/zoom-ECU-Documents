# IAR project DAC_SignalsGeneration2.ewp, settings and files
configuration DAC_SignalsGeneration2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G474xx; USE_NUCLEO_64
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32G4xx_Nucleo; C:/Users/David Tolsma/STM32Cube/Repository/STM32Cube_FW_G4_V1.1.0/Drivers/STM32G4xx_HAL_Driver/Inc; C:/Users/David Tolsma/STM32Cube/Repository/STM32Cube_FW_G4_V1.1.0/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; C:/Users/David Tolsma/STM32Cube/Repository/STM32Cube_FW_G4_V1.1.0/Drivers/CMSIS/Device/ST/STM32G4xx/Include; C:/Users/David Tolsma/STM32Cube/Repository/STM32Cube_FW_G4_V1.1.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DAC_SignalsGeneration2.hex
  ILINK.IlinkOutputFile: DAC_SignalsGeneration2.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../../../../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
    C:/Users/David Tolsma/STM32Cube/Repository/STM32Cube_FW_G4_V1.1.0/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
